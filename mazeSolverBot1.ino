char path[100] = " ";
unsigned char pathLength = 0; 
int pathIndex = 0; 
   
    
         
    #define e1 9 //m2 
    #define e2 8  //m1
    #define d1 7 //m4 
    #define d2 12  //m3
 
    int trigger_front = A4; 
    int echo_front = A5; 
    
    int trigger_right = A2;
    int echo_right = A3;
    
    int trigger_left = A0;
    int echo_left = A1;
      
    void setup()
    {
        pinMode(trigger_front, OUTPUT); 
        pinMode(echo_front, INPUT);
        
        pinMode(trigger_right, OUTPUT);
        pinMode(echo_right, INPUT);        
        
        pinMode(trigger_left, OUTPUT);
        pinMode(echo_left, INPUT);
       
    
     
        pinMode(e1, OUTPUT);
        pinMode(e2, OUTPUT);
        pinMode(d1, OUTPUT);
        pinMode(d2, OUTPUT);      
        delay(5000);

        Serial.begin(9600);
    }
    
    
    void loop()
    {
      
     
     long duration_front, duration_right,duration_left, left,right,front; 
     
     
     digitalWrite(trigger_front, LOW);  
     delayMicroseconds(2);               
     digitalWrite(trigger_front, HIGH);   
     delayMicroseconds(5);               
     digitalWrite(trigger_front, LOW);  
     duration_front = pulseIn(echo_front, HIGH); 
     Serial.print("front");
     front = duration_front*0.034/2;
     Serial.println(front);
    
     digitalWrite(trigger_right, LOW);
     delayMicroseconds(2);
     digitalWrite(trigger_right, HIGH);
     delayMicroseconds(5);
     digitalWrite(trigger_right, LOW); 
      Serial.print("right");
     duration_right = pulseIn(echo_right, HIGH);
     right = duration_right*0.034/2;
      Serial.println(right);
    
     digitalWrite(trigger_left, LOW);
     delayMicroseconds(2);
     digitalWrite(trigger_left, HIGH);
     delayMicroseconds(5);
     digitalWrite(trigger_left, LOW); 
     duration_left = pulseIn(echo_left, HIGH);
      Serial.print("left");
     left = duration_left*0.034/2; 
      Serial.println(left);
     
      //pulseOff Block
     analogWrite(e1, 0);            
     analogWrite(e2, 0);              
     analogWrite(d1, 0);            
     analogWrite(d2, 0);            
     
    
       if(front >8) 
           
           
           if(left >7 && left< 13) 
             {               
          
           
               analogWrite(e1, 120);
               analogWrite(e2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, 120);                                                        
             }



           if(left >=13)  
             {
              
           
               analogWrite(e1, 120);
               analogWrite(e2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, 120);                               
             }
             
                 
           if(left <=7)   
             {
           
               analogWrite(e1, 120);
               analogWrite(e2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, 120);                   
             }
         }


   
              
       if(right <=20 && left>20 && front <=8)
       Left(); 
       if(right >20 && left>20 && front <=8) 
       Left(); 
                                                            
       if(left<=20 && right>20 && front <=8) 
       Right(); 
       
       if(left<=20 && right<=20 && front<=8) uturn(); 
    }  

      
       
    void Right() 
      {
       
       
        analogWrite(e1, 0);
        analogWrite(e2, 90);
        analogWrite(d1, 0);
        analogWrite(d2, 90);
        delay(700);      
        
      }
    
    void Left() 
      {
        
    
        
      
        
        analogWrite(e1, 90);
        analogWrite(e2, 0);
        analogWrite(d1, 90);
        analogWrite(d2, 0);             
        delay(800);
               
      }
    
    void uturn()
      {


  
      
           
        analogWrite(e1, 90);
        analogWrite(e2, 0);
        analogWrite(d1, 90);
        analogWrite(d2, 0);
        delay(1200); 
         
      }   
  
    
    
    
